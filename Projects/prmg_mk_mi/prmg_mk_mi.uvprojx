# Keil uVision project prmg_mk_mi.uvprojx, settings and files
target prmg_mk_mi (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: prmg_mk_mi
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: INC_FREERTOS_H,__TARGET_FPU_VFP,__CC_ARM
  c include: ..\..\3rdPartyLIB\CMSIS\CM4\CoreSupport;..\..\3rdPartyLIB\CMSIS\CM4\DeviceSupport\STM32F4xx\startup;..\..\3rdPartyLIB\STM32F4xx_StdPeriph_Driver\inc;..\..\3rdPartyLIB\freertos_823\config;..\..\3rdPartyLIB\freertos_823\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StdPeriph_Driver
    ../../3rdPartyLIB/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_usart.c misc.c stm32f4xx_rcc.c stm32f4xx_pwr.c
    ../../3rdPartyLIB/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx.h
  group Startup
    ../../3rdPartyLIB/CMSIS/CM4/DeviceSupport/STM32F4xx/startup/: system_stm32f4xx.c
    ./: startup_stm32f4xx.s
  group src
    ./: Main.cpp
    ./src/: prmg_mk_mi_init.c prmg_mk_mi_isr.c prmg_mk_mi_delay.c
  group freertos
    ../../3rdPartyLIB/freertos_823/src/: tasks.c heap_2.c port.c list.c event_groups.c croutine.c timers.c queue.c
